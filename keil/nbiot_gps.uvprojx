# Keil uVision project nbiot_gps.uvprojx, settings and files
target nbiot_gps (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nbiot_gps
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\kernel\core;..\Source\kernel\firmlib\STM32F10x_FWLib\inc;..\Source\hardware\inc;..\Source\user\inc;..\Source\user\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Source/kernel/core/: core_cm3.c startup_stm32f10x_hd.s
  group kernel
    ../Source/kernel/firmlib/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hardware
    ../Source/hardware/src/: adc.c delay.c led.c stmflash.c sys.c timer.c usart.c wdg.c m5310_hard.c nbiot_power.c dht11.c
  group user
    ../Source/user/src/: main.c chip_flash.c common.c config.c oscrc32.c PUBLIC.C user_m5310.c m5310_onenet.c
    ../Source/user/System/: stm32f10x_it.c system_stm32f10x.c
